# Keil uVision project GPTIM_InputCapture.uvprojx, settings and files
target stm32f4 (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPTIM_InputCapture
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group app
    ./: main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.2
